# in EPEL 10.1

SPECFILE = "${PN}.spec"
RPM_SOURCES_SUBDIR = "."

inherit srpm-intree
