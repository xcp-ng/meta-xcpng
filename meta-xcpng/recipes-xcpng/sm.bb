inherit srpm-intree

RDEPENDS:sm = " \
 device-mapper-multipath \
 libcgroup-tools \
 lvm2 \
 python3-bitarray \
 sg3_utils \
 xcp-ng-release-presets \
"
